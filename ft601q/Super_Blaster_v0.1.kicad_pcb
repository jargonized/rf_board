# Repository jargonized/rf_board

## KiCad design ft601q/Super_Blaster_v0.1.kicad_pcb

Board: 4 copper layers, 55.0 x 35.0 mm, 76 parts (29 on the bottom side), 102 nets.

Parts:
C1, C2, C3, C4, C5: .1u; C_0402
C6, C7: 18p; C_0402
C8: 4.7uF; C_0603
C9, C10, C27, C29: .1uF; C_0402
C11: 1nF; C_0402
C12, C13, C14, C15: 22u; C_0603
C16, C18, C19, C20, C21, C22, C23, C24, C25, C30, C31, C32, C33, C34, C35, C36, C37, C38, C39, C40, C41, C42, C43, C44: .1u; C_0402_NoSilk
C17: 10u; C_0603
C26, C28: 1uF; C_0402
D1: D; D_0402_1005Metric
J1: USB_TypeC_AMP_12401610E4#2A; USB_TypeC_Right_Angle_SMD_THT_12401610E4#2A
J2, J3: Conn_02x25_Odd_Even; Pin_Header_Straight_2x25_Pitch1.27mm_tight_SMD
L1, L2: 2.2u; L_1008
M1: CLOCK_EN; Crystal_SMD_2520-4Pin_2.5x2.0mm
R1, R6: 5.1K_10%; R_0402
R2, R3, R4, R5, R18, R19: ?; R_0402
R7: 10K; R_0402
R8: 1.6K 1%; R_0402
R9, R10: 10k; R_0402
R11: 1M; R_0402
R12: 4k7; R_0402
R13: 9k1; R_0402
R14: 5k1; R_0402
R15: 1k6; R_0402
R17: 100; R_0603
U1: MCP6L94; SSOP-14
U2: iCE40-HX8K-CT256; caBGA_256_.8p_14x14mm
U3: FUSB340; FUSB340_Custom
U4: FT601Q; QFN_76_PAD
U5, U6: REG_EN_GND_LX_VIN_NC_FB; TSOT-23-6
Y1: 30MHz; Crystal_SMD_2016-4Pin_2.0x1.6mm

Connections:
1v2: C15.2, C38.1, C39.1, C40.1, C41.1, C42.1, C43.1, L2.2, R14.1, R17.1, U2.A14, U2.F6, U2.F10, U2.K6, U2.K10, U2.L2
3v3: C9.1, C14.2, C28.2, C29.2, C30.1, C31.1, C32.1, C33.1, C34.1, C35.1, C36.1, C37.1, C44.1, D1.2, J2.49, J3.47, J3.48, L1.2, M1.1, M1.4, R2.1, R4.1, R7.1, R9.1, R10.2, R12.1, U1.4, U2.C15, U2.H10, U2.H15, U2.K8, U2.N13, U2.N15, U2.P3, U2.R8, U2.R13, U3.17, U4.14, U4.20, U4.24, U4.28, U4.38, U4.49, U4.59, U4.68
/Bottom_Interface/1.5A_DET: U1.7, U2.T16
/Bottom_Interface/3A_DET: U1.8, U2.T15
/Bottom_Interface/50MHz: M1.3, U2.K9
/Bottom_Interface/CLK: U2.H11, U4.58
/Bottom_Interface/GPIO0: U2.R4, U4.17
/Bottom_Interface/GPIO1: U2.R3, U4.18
/Bottom_Interface/~OE: U2.T6, U4.13
/Bottom_Interface/~RD: U2.R6, U4.12
/Bottom_Interface/~RESET: C5.2, R7.2, U2.R5, U4.15
/Bottom_Interface/~RXF: U2.T9, U4.9
/Bottom_Interface/~SIWU: U2.T8, U4.10
/Bottom_Interface/~TXE: U2.T10, U4.8
/Bottom_Interface/~WR: U2.T7, U4.11
/Bottom_Interface/~Wakeup: U2.T5, U4.16
/CBSEL_0: J2.40, U2.K11
/CBSEL_1: J2.42, U2.P13
/CDONE: J2.39, R10.1, U2.M10
/MEM_SCK: J2.43, U2.R11
/MEM_SDI: J2.44, U2.P11
/MEM_SDO: J2.46, U2.P12
/MEM_SS: J2.45, U2.R12
/USB_Connection/CC1: J1.A5, R1.1, R18.1, U1.13
/USB_Connection/CC2: J1.B5, R6.1, R19.2, U1.12
/USB_Connection/CCV: U1.1, U1.2, U1.5, U1.10
/USB_Connection/SS_RX1_N: J1.B10, U3.11
/USB_Connection/SS_RX1_P: J1.B11, U3.10
/USB_Connection/SS_RX2_N: J1.A10, U3.9
/USB_Connection/SS_RX2_P: J1.A11, U3.8
/USB_Connection/SS_RX_N: U3.4, U4.34
/USB_Connection/SS_RX_P: U3.5, U4.35
/USB_Connection/SS_TX1_N: C2.1, J1.A3
/USB_Connection/SS_TX1_P: C4.2, J1.A2
/USB_Connection/SS_TX2_N: C1.1, J1.B2
/USB_Connection/SS_TX2_P: C3.2, J1.B3
/USB_Connection/SS_TX_N: U3.1, U4.31
/USB_Connection/SS_TX_P: U3.2, U4.32
/USB_Connection/Switch: U1.14, U3.6
/USB_Connection/T1_N: C2.2, U3.16
/USB_Connection/T1_P: C4.1, U3.15
/USB_Connection/T2_N: C1.2, U3.14
/USB_Connection/T2_P: C3.1, U3.13
/USB_Connection/USB_D_N: J1.A7, J1.B7, U4.25
/USB_Connection/USB_D_P: J1.A6, J1.B6, U4.23
/USB_Connection/Xi: C7.2, U4.21, Y1.3
/USB_Connection/Xo: C6.2, U4.22, Y1.1
/VLEFT: C18.1, C19.1, C20.1, C21.1, J2.47, J2.48, U2.E1, U2.G6, U2.J6, U2.N1
/VTOP: C22.1, C23.1, C24.1, C25.1, J3.45, J3.46, U2.A3, U2.A8, U2.A13, U2.F8
/ho: U2.A1, U2.A2
/~CRESET: J2.41, R9.2, U2.N11
BE_0: U2.T14, U4.4
BE_1: U2.T13, U4.5
BE_2: U2.T11, U4.6
BE_3: U2.R10, U4.7
D0: U2.B16, U4.40
D1: U2.C16, U4.41
D2: U2.D14, U4.42
D3: U2.D16, U4.43
D4: U2.E14, U4.44
D5: U2.D15, U4.45
D6: U2.E13, U4.46
D7: U2.E16, U4.47
D8: U2.F14, U4.50
D9: U2.F16, U4.51
D10: U2.F12, U4.52
D11: U2.F15, U4.53
D12: U2.F13, U4.54
D13: U2.G16, U4.55
D14: U2.G12, U4.56
D15: U2.G15, U4.57
D16: U2.J15, U4.60
D17: U2.J16, U4.61
D18: U2.K15, U4.62
D19: U2.K16, U4.63
D20: U2.L14, U4.64
D21: U2.L16, U4.65
D22: U2.M15, U4.66
D23: U2.M16, U4.67
D24: U2.M14, U4.69
D25: U2.N16, U4.70
D26: U2.P15, U4.71
D27: U2.P16, U4.72
D28: U2.P14, U4.73
D29: U2.R16, U4.74
D30: U2.R15, U4.75
D31: U2.R14, U4.76
Earth: C10.2, C11.2, J1.0, R11.1
GND: C5.1, C6.1, C7.1, C8.2, C9.2, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.1, C27.1, C28.1, C29.1, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, C42.2, C43.2, C44.2, J1.A1, J1.A12, J1.B1, J1.B12, J2.1, J2.2, J2.7, J2.8, J2.13, J2.14, J2.19, J2.20, J2.25, J2.26, J2.31, J2.32, J2.37, J2.38, J2.50, J3.41, J3.42, M1.2, R1.2, R3.2, R5.2, R6.2, R8.2, R11.2, R13.1, R15.1, U1.11, U2.A4, U2.A12, U2.E15, U2.G7, U2.G8, U2.G9, U2.H7, U2.H8, U2.H9, U2.J7, U2.J8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
unnamed: C16.1, C17.1, U2.E7, U2.N8
unnamed: C16.2, C17.2, R17.2, U2.E8, U2.L8
unnamed: D1.1, U2.E12
unnamed: L1.1, U5.3
unnamed: L2.1, U6.3
unnamed: R2.2, R3.1, U1.6
unnamed: R4.2, R5.1, U1.9
unnamed: R8.1, U4.27
unnamed: R12.2, R13.2, U5.6
unnamed: R14.2, R15.2, U6.6
unnamed: R18.2, R19.1, U1.3
USB_V: C12.2, C13.2, J1.A4, J1.A9, J1.B4, J1.B9, J3.49, J3.50, U4.37, U5.1, U5.4, U6.1, U6.4
VD10: C8.1, C26.2, C27.2, U4.2, U4.3, U4.30, U4.33, U4.39, U4.48

## Commit log

2022-05-28 kicad_version_change
